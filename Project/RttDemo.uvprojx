# Keil uVision project RttDemo.uvprojx, settings and files
target RttDemo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RttDemo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_RTT
  c include: ..\Application;..\Application\sensor;..\Common\APL\apl_at;..\Common\APL\apl_rf;..\Common\APL\apl_rf\wifi;..\Common\APL\apl_rf\zxbee;..\Application\dev;..\Common\APL\apl_delay;..\Common\BSP\bsp_flash;..\Common\BSP\bsp_i2c;..\Common\BSP\bsp_uart;..\Common\DEV\dev_serial;..\Common\DEV\dev_uart;..\Common\DRV\drv_led;..\Common\DRV\drv_key;..\SDK\Config;..\SDK\CMSIS\CM3\CoreSupport;..\SDK\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\SDK\STM32F10x_StdPeriph_Driver\inc;..\rt-thread\Port;..\rt-thread\libcpu;..\rt-thread\include;..\rt-thread\include\libc;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Application/: main.c
    ../Application/sensor/: sensor.c sensor_thread.c
  group Application/dev
    ../Application/dev/: drv_fan.c htu21d.c dht11.c water_sensor.c
  group Common/APL
    ../Common/APL/apl_at/: at_thread.c at_app.c at_hw.c
    ../Common/APL/apl_rf/: rf_thread.c rf_if_app.c rf_if_hw.c
    ../Common/APL/apl_rf/wifi/: wifi_drv.c
    ../Common/APL/apl_rf/zxbee/: zxbee.c
    ../Common/APL/apl_delay/: delay.c
  group Common/BSP
    ../Common/BSP/bsp_flash/: flash.c
    ../Common/BSP/bsp_i2c/: iic.c iic2.c
    ../Common/BSP/bsp_uart/: uart1.c uart2.c uart3.c
  group Common/DEV
    ../Common/DEV/dev_serial/: serial.c
  group Common/DRV
    ../Common/DRV/drv_led/: led.c
    ../Common/DRV/drv_key/: key.c
  group SDK/Config
    ../SDK/Config/: stm32f10x_conf.h stm32f10x_it.c
  group SDK/CMSIS
    ../SDK/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c
    ../SDK/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group SDK/STM32F10x_StdPeriph_Driver
    ../SDK/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group rtthread/Port
    ../rt-thread/Port/: rtconfig.h board.c
  group rtthread/libcpu
    ../rt-thread/libcpu/: context_rvds.S cpuport.c
  group rtthread/src
    ../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rtthread/components/drivers
    ../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
